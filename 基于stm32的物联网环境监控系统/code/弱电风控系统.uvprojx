# Keil uVision project 弱电风控系统.uvprojx, settings and files
target 基于stm32的物联网监控系统 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 基于stm32的物联网监控系统
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;..\stm32;.\User;.\Library;.\system;.\Hardware;.\Hardware;.\NET;.\App;.\Middlewares\FreeRTOS\include;.\Middlewares\FreeRTOS\portable\MemMang;.\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s stm32f10x.h core_cm3.c core_cm3.h system_stm32f10x.c
  group Librariy
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.c stm32f10x_bkp.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_exti.c stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.h stm32f10x_it.c common_types.c common_types.h Sensors.c Sensors.h FreeRTOSConfig.h
    ./Hardware/: test.c
  group System
    ./system/: delay.c delay.h MyI2C.h
    ./System/: Timer.c Timer.h MyI2C.c
    ./Hardware/: MY_DMA.c MY_DMA.h
  group Hardware
    ./Hardware/: KEY.c KEY.h LED.c LED.h Buzzer.h Buzzer.c PWM.c PWM.h Motor.c Motor.h ADC2.c ADC2.h usart.c usart.h SHT30.c SHT30.h OLED.c OLED.h OLED_Data.c OLED_Data.h
  group Net
    ./NET/: base64.c base64.h Common.h esp8266.c esp8266.h hmac_sha1.c hmac_sha1.h MqttKit.c MqttKit.h onenet.c onenet.h cJSON.c cJSON.h
  group Application
    ./App/: key_handler.c key_handler.h OLED_handler.c OLED_Handler.h Platform_Handler.c Platform_Handler.h
  group MIddlewares/FreeRTOS_CORE
    ./Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group MIddlewares/FreeRTOS_PORT
    ./Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ./Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
